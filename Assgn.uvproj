# Keil uVision project Assgn.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C451 NXP
  cpu: IRAM(0-0x7F) CLOCK(20000000)
  output: Assgn
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: assginment.c
